# Keil uVision project BluePill_mbedOS.uvprojx, settings and files
target BluePill_mbedOS (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BluePill_mbedOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -D__ASSERT_MSG -DMBED_BUILD_TIMESTAMP=1481286133.09 -DTARGET_STM32F1 --no_rtti -DTARGET_STM32F103RB -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DTARGET_NUCLEO_F103RB -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M3 -DTARGET_FF_MORPHO -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M3 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: .;src;src/MsgBroker;.\src\Shifter;.\src\Stepper;.\src\TrunkController;esp8266-driver;esp8266-driver/ESP8266;esp8266-driver/ESP8266/ATParser;esp8266-driver/ESP8266/ATParser/BufferedSerial;esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer;mbed-os/.;mbed-os/docs;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/greentea-client/source;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/source;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/source;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/importer;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/src;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/platform/src;mbed-os/features/nanostack;mbed-os/features/storage;mbed-os/features/netsocket;mbed-os/cmsis;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/rtos;mbed-os/rtos/rtx;mbed-os/rtos/rtx/TARGET_CORTEX_M;mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3;mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM;mbed-os/hal;mbed-os/hal/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/targets;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32F1;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device;mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD;mbed-os/targets/TARGET_STM/TARGET_STM32F1/device;.\src\test;.\src\SerialTerminal;.\src\IKModel
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M3,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/stm32f103xb.sct
  group ATParser
    esp8266-driver/ESP8266/ATParser/: ATParser.cpp ATParser.h
  group BluePill_mbedOS
    ./: main.cpp mbed_config.h
  group test
    ./src/test/: test.h test_CloudManager.cpp test_TrunkController.cpp test_SerialTerminal.cpp
  group Buffer
    esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer/: MyBuffer.cpp MyBuffer.h
  group BufferedSerial
    esp8266-driver/ESP8266/ATParser/BufferedSerial/: BufferedPrint.c BufferedSerial.cpp BufferedSerial.h
  group ESP8266
    esp8266-driver/ESP8266/: ESP8266.cpp ESP8266.h
  group esp8266-driver
    esp8266-driver/: ESP8266Interface.cpp ESP8266Interface.h
  group MsgBroker
    src/MsgBroker/: Heap.h List.h List_tpp.h MsgBroker.cpp MsgBroker.h
    ./src/MsgBroker/: FPointer.h
  group SerialTerminal
    ./src/SerialTerminal/: SerialTerminal.cpp SerialTerminal.h Logger.h
  group Robot
    ./src/Shifter/: Shifter.h Shifter.cpp
    ./src/Stepper/: Stepper.h Stepper.cpp
    ./src/TrunkController/: TrunkController.h TrunkController.cpp
    ./src/IKModel/: IKModel.h IKModel.cpp IK3.cpp IK3.h IK9.cpp IK9.h
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
  group TARGET_NUCLEO_F103RB
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group TARGET_STM
    mbed-os/targets/TARGET_STM/: mbed_rtx.h stm_spi_api.c trng_api.c
  group TARGET_STM32F1
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/: analogin_api.c can_api.c common_objects.h device.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c PeripheralPins.h pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/: startup_stm32f103xb.S sys.cpp
  group cmsis
    mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group device
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.c hal_tick.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
    mbed-os/targets/TARGET_STM/TARGET_STM32F1/device/: stm32_hal_legacy.h stm32f1xx_hal.c stm32f1xx_hal.h stm32f1xx_hal_adc.c stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.c stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.c stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.c stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.c stm32f1xx_hal_crc.h stm32f1xx_hal_dac.c stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.c stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.c stm32f1xx_hal_eth.h stm32f1xx_hal_flash.c stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.c stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.c stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.c stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.c stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.c stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.c stm32f1xx_hal_nand.h stm32f1xx_hal_nor.c stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.c stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.c stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.c stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.c stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.c stm32f1xx_hal_spi.h stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_sram.h stm32f1xx_hal_tim.c stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.c stm32f1xx_hal_uart.h stm32f1xx_hal_usart.c stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.c stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.c stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.c stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.c stm32f1xx_ll_usb.h
  group drivers
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.cpp Ethernet.h FileBase.cpp FileBase.h FileHandle.h FileLike.cpp FileLike.h FilePath.cpp FilePath.h FileSystemLike.cpp FileSystemLike.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LocalFileSystem.cpp LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Stream.cpp Stream.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h
  group equeue
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
  group events
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h
  group greentea-client
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
  group hal
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/hal/hal/: emac_api.h
  group inc
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group mbed-os
    mbed-os/: mbed.h
  group mbedtls
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group netsocket
    mbed-os/features/netsocket/: CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
  group platform
    mbed-os/platform/: Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_alloc_wrappers.cpp mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_preprocessor.h mbed_rtc_time.cpp mbed_semihost_api.c mbed_stats.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp platform.h PlatformMutex.h retarget.cpp rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
  group rtos
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group source
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp test_env.cpp
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
  group src
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
  group storage_abstraction
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group unity
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group utest
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
